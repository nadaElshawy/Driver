# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: test
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s gpio_app_test.c
    ../APP/: app_gpio.c app_uart.c app_gpio.h app_uart.h
    ../HAL/: gpio.c sysctrl.c uart.c gpio.h sysctrl.h uart.h
    ../SL/: NVICInterruptHandler.c NVICInterruptHandler.h
    ../RAL/: hw_gpio.h hw_sysctrl.h hw_types.h hw_uart.h types.h
